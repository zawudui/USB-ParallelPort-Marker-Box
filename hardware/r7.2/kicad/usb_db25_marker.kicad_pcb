# Repository zawudui/USB-ParallelPort-Marker-Box

File README.md:

# USB-DB25 Marker Box

**An open-hardware USB-to-DB25 event marker interface for EEG/ERP and experimental research.**

开发者与个人发布者：**Li Jingwei**。中文说明见 [README_CN.md](README_CN.md)。

Developed and published by **Li Jingwei**. This personal source snapshot is based on the previously curated project files; third-party credits and licences are preserved. This repository contains the r7.2 hardware design, STM32F411 firmware, MATLAB host client, enclosure CAD, manufacturing source files, and validation notes.

> [!IMPORTANT]
> **Release candidate / prototype status.** This repository is being prepared for its first public release. The hardware is an experimental research accessory, not a medical device. Compatibility with a particular EEG/DAQ system must be verified against that system's DB25 pinout, input voltage, polarity, pulse width, and trigger sampling behavior. Do not connect it to valuable acquisition equipment until the electrical interface has been independently checked.

Personal repository: [zawudui/USB-ParallelPort-Marker-Box](https://github.com/zawudui/USB-ParallelPort-Marker-Box).

## What it is

- USB-C connection to a host computer.
- Eight active-high digital marker outputs on DB25 pins 2–9 (D0–D7).
- Isolated-side signal reference on DB25 pins 18–25 (GND_ISO).
- STM32F411-based firmware with a framed command protocol.
- MATLAB client and examples.
- KiCad schematic/PCB sources and a two-piece screwless PA12 snap-fit enclosure.

## Validation summary (2026-11-09)

One prototype board was recovered and tested on a bench:

- 100/100 command/ACK transactions passed; measured host write-to-complete-ACK round trip: 0.1796–0.3522 ms under the recorded setup.
- One DB25 D1 pulse measured approximately 2.002 ms.
- One unloaded-DB25 MCU-output-to-DB25-output comparison showed approximately 31 ns difference, **uncalibrated for probe/channel skew**. Ordinary oscilloscope probe grounds temporarily commoned host ground and GND_ISO during this capture, so it is not evidence of isolation performance.

## Hardware interface

| DB25 pin | Signal | Description |
|---|---|---|
| 2–9 | D0–D7 | Eight active-high marker bits |
| 18–25 | GND_ISO | Isolated-side signal reference |
| 1, 10–17 | NC | Not connected |

Always confirm connector orientation from the mating-face view and verify the receiving instrument's pin assignment before connection.

## Build and use

- Hardware design: [hardware/r7.2](hardware/r7.2/)
- Firmware build and host tests: [firmware](firmware/)
- MATLAB client: [tools/matlab](tools/matlab/)
- Enclosure CAD: [r7.2 screwless PA12 snap-fit enclosure](hardware/enclosure/r7.2/snap-fit-pa12/)
- Manufacturing notes: [hardware/r7.2/manufacturing](hardware/r7.2/manufacturing/)
- Electrical interface and limitations: [electrical specifications](docs/hardware/electrical-specifications.md)
- Validation scope: [validation notes](docs/validation/README.md)

The firmware's current USB VID/PID values (0x0483:0x5740) are **ST example placeholder IDs**, not a VID/PID assigned to this project. Do not treat them as a product identifier or ship a commercial product with them as if assigned.

## Licensing

- Hardware design files: CERN-OHL-S-2.0, subject to exclusions in [THIRD_PARTY_NOTICES.md](THIRD_PARTY_NOTICES.md).
- Firmware and host-side software: MIT.
- Original documentation: CC BY 4.0.
- Third-party materials retain their own licences.

## Release readiness

See [release checks](docs/release/RELEASE_GATE.md) and [personal repository upload](docs/release/PERSONAL_REPO_MIGRATION.md). Run `python tools/release_audit.py` before upload. The source package contains no private Git history, supplier orders or prebuilt firmware.

## Attribution

Copyright (c) 2026 Li Jingwei and contributors, for their original contributions. KiCad-derived library material has separate attribution and licensing. See individual licence files and notices.

## KiCad design hardware/r7.2/kicad/usb_db25_marker.kicad_pcb

File hardware/r7.2/kicad/README.md:

# KiCad project

Open usb_db25_marker.kicad_pro in KiCad 9. The project includes the r7.2 schematic, PCB, design rules and project-local symbol/footprint libraries.

The standard KiCad library references in sym-lib-table are resolved through the installed KiCad library environment. Install the standard KiCad symbol and footprint libraries before editing.

The project-local MarkerBox libraries contain the custom TLV75533/TPS61085/TPD4E05U06 symbols and the NorComp DB25 / TRACO TMR 0511 footprints used by this design. Review THIRD_PARTY_NOTICES.md before redistributing or adapting any library-derived geometry.

The two project-local footprint files with identified KiCad ancestry and the project-local symbol library require specific upstream provenance checks before public distribution. Refer to [the KiCad library attribution record](../../../third_party/KICAD-LIBRARIES-LICENSE.md) and [release gates](../../../docs/release/RELEASE_GATE.md). Do not treat the broad hardware CERN-OHL-S-2.0 licence as replacing upstream footprint-library terms.

Schematic: usb_db25_marker.kicad_sch, USB CDC to DB25 8-bit Marker Adapter

Parts:
C1, C2, C3, C22, C23, C24, C25, C30, C31, C32, C33, C34, C35, C36, C37, C40, C205: 100nF; C_0603_1608Metric
C4: 4.7uF; C_0603_1608Metric
C5, C6: 8.2pF; C_0603_1608Metric
C7: 2.2uF; C_0603_1608Metric
C10, C21: 10uF; C_0603_1608Metric
C11: 22uF; C_0603_1608Metric
C20, C201, C203, C204: 10uF/25V; C_0805_2012Metric
C202: 1uF/16V; C_0603_1608Metric
C206: 3.3nF; C_0603_1608Metric
C207: 220nF; C_0603_1608Metric
D1: TPD1E10B06DPYR; D_0402_1005Metric
D201: SS34; D_SMA
J1: USB4105-GF-A; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: 182-025-213R531; DSUB-25_Socket_NorComp_182-025-213R531
J3: SWD; PinHeader_1x04_P2.54mm_Vertical
L201: 6.8uH; L_Coilcraft_XAL7030-682
Q1: AO3401A; SOT-23
Q2, Q3: 2N7002; SOT-23
R10, R11, R12, R13, R14, R15, R16, R17, R18: 330 1%; R_0603_1608Metric
R20, R21, R22, R23, R24, R25, R26, R27, R28, R71, R98: 1k; R_0603_1608Metric
R30, R31, R32, R33, R34, R35, R36, R37, R97: 100; R_0603_1608Metric
R40, R41, R42, R43, R44, R45, R46, R47, R80, R81, R82, R83, R85, R86, R87, R88: 47k; R_0603_1608Metric
R50, R51, R52, R93: 10k; R_0603_1608Metric
R60, R61: 5.1k; R_0603_1608Metric
R70: 33k; R_0603_1608Metric
R72, R84: 4.7k; R_0603_1608Metric
R89: 0R; R_0603_1608Metric
R90: 74.5k; R_0603_1608Metric
R91: 18.2k; R_0603_1608Metric
R92: 13k; R_0603_1608Metric
R94, R95: 100k; R_0603_1608Metric
R96: 3.3k; R_0603_1608Metric
TP201: VBUS_SW; TestPoint_Pad_D1.5mm
TP202, TP203: ISO_VIN; TestPoint_Pad_D1.5mm
U1: STM32F411CEU6; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
U2: TMR 0511; TMR2_0511_SIP8
U3, U4, U5, U6, U7, U8, U9, U10, U11: 6N137; DIP-8_W7.62mm
U12, U13: 74HC14; SOIC-14_3.9x8.7mm_P1.27mm
U14: TLV75533PDBVR; SOT-23-5
U15, U16: SN74LVC06AD; SOIC-14_3.9x8.7mm_P1.27mm
U17: TPD2E2U06DCKR; SOT-323_SC-70
U18, U19: TPD4E05U06DQAR; USON-10_2.5x1.0mm_P0.5mm
U20: TPS61085PWR; TSSOP-8_4.4x3mm_P0.65mm
Y1: 25MHz 8pF NX3225GA; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C1.2, C2.2, C3.2, C4.2, C11.2, C24.1, C25.1, J3.1, R52.2, U1.1 (VBAT), U1.9 (VDDA), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U14.5 (OUT), U15.14 (VCC), U16.14 (VCC)
/BOOST_COMP: R92.1, U20.1 (COMP)
/BOOST_EN: R93.2, R94.1, U20.3 (EN)
/BOOST_FB: R90.2, R91.1, U20.2 (FB)
/BOOST_SS: C205.1, U20.8 (SS)
/BOOST_SW: D201.2 (A), L201.2, U20.5 (SW)
/BOOT0: R51.2, U1.44 (BOOT0)
/CC1: J1.A5 (CC1), R60.1
/CC2: J1.B5 (CC2), R61.1
/COMP_MID: C206.1, R92.2
/DB25_D0: J2.2, R30.2, R40.2, U18.1 (D1+)
/DB25_D1: J2.3, R31.2, R41.2, U18.2 (D1-)
/DB25_D2: J2.4, R32.2, R42.2, U18.4 (D2+)
/DB25_D3: J2.5, R33.2, R43.2, U18.5 (D2-)
/DB25_D4: J2.6, R34.2, R44.2, U19.1 (D1+)
/DB25_D5: J2.7, R35.2, R45.2, U19.2 (D1-)
/DB25_D6: J2.8, R36.2, R46.2, U19.4 (D2+)
/DB25_D7: J2.9, R37.2, R47.2, U19.5 (D2-)
/GND_ISO: C21.1, C22.1, C23.2, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C40.1, J2.18, J2.19, J2.20, J2.21, J2.22, J2.23, J2.24, J2.25, R40.1, R41.1, R42.1, R43.1, R44.1, R45.1, R46.1, R47.1, R50.1, U2.7 (-VOUT), U3.5 (GND), U4.5 (GND), U5.5 (GND), U6.5 (GND), U7.5 (GND), U8.5 (GND), U9.5 (GND), U10.5 (GND), U11.5 (GND), U12.7 (GND), U13.7 (GND), U13.9, U13.11, U13.13, U18.3 (GND), U18.8 (GND), U19.3 (GND), U19.8 (GND)
/ISO_BLEED: Q3.3 (D), R97.2
/ISO_PWR_EN: R71.2, R72.1, U1.38 (PA15)
/LED_K0: U3.3 (C), U15.8 (4Y)
/LED_K1: U4.3 (C), U15.10 (5Y)
/LED_K2: U5.3 (C), U15.12 (6Y)
/LED_K3: U6.3 (C), U16.2 (1Y)
/LED_K4: U7.3 (C), U16.8 (4Y)
/LED_K5: U8.3 (C), U16.10 (5Y)
/LED_K6: U9.3 (C), U16.12 (6Y)
/LED_K7: U10.3 (C), U15.4 (2Y)
/LED_KRDY: U11.3 (C), U15.2 (1Y)
/MARKER_D0: R80.1, U1.18 (PB0), U15.9 (4A)
/MARKER_D1: R81.1, U1.19 (PB1), U15.11 (5A)
/MARKER_D2: R82.1, U1.20 (PB2), U15.13 (6A)
/MARKER_D3: R83.1, U1.39 (PB3), U16.1 (1A)
/MARKER_D4: R84.1, U1.40 (PB4), U16.9 (4A)
/MARKER_D5: R85.1, U1.41 (PB5), U16.11 (5A)
/MARKER_D6: R86.1, U1.42 (PB6), U16.13 (6A)
/MARKER_D7: R87.1, U1.43 (PB7), U15.3 (2A)
/MARKER_READY: R88.1, U1.45 (PB8), U15.1 (1A)
/NRST: R52.1, U1.7 (NRST)
/OSC_IN: C5.1, U1.5 (PH0), Y1.1
/OSC_OUT: R89.1, U1.6 (PH1)
/OSC_OUT_XT: C6.1, R89.2, Y1.3
/Q1_GATE: C207.1, Q1.1 (G), R70.1, R96.1, R98.1
/Q2_DRAIN: Q2.3 (D), R96.2
/Q3_GATE: Q3.1 (G), R98.2
/READY_ISO: R50.2, U3.7 (EN), U4.7 (EN), U5.7 (EN), U6.7 (EN), U7.7 (EN), U8.7 (EN), U9.7 (EN), U10.7 (EN), U13.6
/SWCLK: J3.3, U1.37 (PA14)
/SWDIO: J3.2, U1.34 (PA13)
/USB_DM: J1.A7 (D-), J1.B7 (D-), U1.32 (PA11), U17.1
/USB_DP: J1.A6 (D+), J1.B6 (D+), U1.33 (PA12), U17.2
/VCAP1: C7.2, U1.22 (VCAP1)
/VCC_ISO: C21.2, C22.2, C23.1, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C40.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, U2.6 (+VOUT), U3.8 (VCC), U4.8 (VCC), U5.8 (VCC), U6.8 (VCC), U7.8 (VCC), U8.8 (VCC), U9.8 (VCC), U10.8 (VCC), U11.7 (EN), U11.8 (VCC), U12.14 (VCC), U13.14 (VCC)
unnamed: Q2.1 (G), R71.1
unnamed: R30.1, U12.2
unnamed: R31.1, U12.4
unnamed: R32.1, U12.6
unnamed: R33.1, U12.8
unnamed: R34.1, U12.10
unnamed: R35.1, U12.12
unnamed: R36.1, U13.2
unnamed: R37.1, U13.4
unnamed: R10.1, U3.2 (A)
unnamed: R20.1, U3.6 (VO), U12.1
unnamed: R11.1, U4.2 (A)
unnamed: R21.1, U4.6 (VO), U12.3
unnamed: R12.1, U5.2 (A)
unnamed: R22.1, U5.6 (VO), U12.5
unnamed: R13.1, U6.2 (A)
unnamed: R23.1, U6.6 (VO), U12.9
unnamed: R14.1, U7.2 (A)
unnamed: R24.1, U7.6 (VO), U12.11
unnamed: R15.1, U8.2 (A)
unnamed: R25.1, U8.6 (VO), U12.13
unnamed: R16.1, U9.2 (A)
unnamed: R26.1, U9.6 (VO), U13.1
unnamed: R17.1, U10.2 (A)
unnamed: R27.1, U10.6 (VO), U13.3
unnamed: R18.1, U11.2 (A)
unnamed: R28.1, U11.6 (VO), U13.5

Notes on the sheet:
r6 DRIVE: R10-R18 = 330 ohm 1% from VBUS; LED cathode sunk by U15/U16 SN74LVC06A. Worst IF 6.15 mA min / 13.8 mA max. See 6N137驱动电流核算-r6.md
USB CDC to DB25 8-bit Marker — Schematic v0.3-r2 (P0 polarity+TMR2+suspend — NOT fab) (NOT frozen for PCB fab)
Design pack v0.3 Adopt: regulated iso DC-DC | 6N137 VE(active-HIGH)+READY | 74HC14 invert-only | Busy NACK | Clear then Gap
MISWIRE WARNING: DB25 Pin18-25 = GND_ISO. Do NOT plug BP TriggerBox Out(Amp) (Pin24 may be +5V). TRIGGER IN / PC0-7 ONLY + dedicated cable.
GPIO map: PB0..PB7=MARKER_D0..D7 (atomic port); PB8=MARKER_READY; PA11=USB_DM; PA12=USB_DP; PA13=SWDIO; PA14=SWCLK; PH0/PH1=HSE 25MHz; PA15=ISO_PWR_EN (Suspend).
ERC note: MCU/USB-C/DB25 symbol pins are annotated by net-name labels; many pin_not_connected remain until pin-exact wires are finished in GUI. Opto channels below are hard-wired.
=== A. USB Device / 3V3 / MCU / SWD (net-name annotated) ===
J1 USB-C Device: connect VBUS, D+/D-, GND, CC1/CC2(5.1k to GND). Optional ESD TBD.
U14: VI=VBUS VO=+3V3 GND=GND (attach pins in GUI if ERC requires)
U1 net binding (provisional):
PB0=MARKER_D0 ... PB7=MARKER_D7
PB8=MARKER_READY
PA11=USB_DM PA12=USB_DP
PA13=SWDIO PA14=SWCLK
PH0=OSC_IN PH1=OSC_OUT
NRST via R52 to +3V3; BOOT0 via R51 to GND
All VDD=+3V3; All VSS=GND
J3 SWD 1=+3V3 2=SWDIO 3=SWCLK 4=GND
=== B. Regulated iso 5V + USB Suspend load switch ===
U2=Traco TMR 0511 REGULATED 2W 5V/400mA (4.5-9Vin). Backup: TMR 1-0511 (1W/200mA SIP-6). Suspend: ISO_PWR_EN=PA15 low cuts Q1.
MCU PA15 = ISO_PWR_EN (active-high enable iso rail)
=== C. READY path (wired) ===
READY: MCU high -> LED on -> VO low -> invert -> READY_ISO high -> enable all data VE. Default READY_ISO low.
=== D. Eight data channels (wired) ===
--- Ch D0 / DB25 Pin 2 ---
--- Ch D1 / DB25 Pin 3 ---
--- Ch D2 / DB25 Pin 4 ---
--- Ch D3 / DB25 Pin 5 ---
--- Ch D4 / DB25 Pin 6 ---
--- Ch D5 / DB25 Pin 7 ---
--- Ch D6 / DB25 Pin 8 ---
--- Ch D7 / DB25 Pin 9 ---
Each ch (r6): VBUS->R1x->6N137 A, C->LED_Kx->LVC06 sink (input MARKER_Dx); VE=READY_ISO; VO+R2x; 74HC14; R3x->DB25_Dx; R4x to GND_ISO. U12=D0-5, U13=D6-7(+READY inv).
=== E. DB25 female ===
-> Pin 2
-> Pin 3
-> Pin 4
-> Pin 5
-> Pin 6
-> Pin 7

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
Board: 2 copper layers, 155.0 x 118.0 mm, 125 parts (0 on the bottom side), 84 nets.

File hardware/r7.2/manufacturing/bom/usb_db25_marker-bom-r7.2-by-ref.csv:

"Ref","Value","Footprint"
"C1","100nF","Capacitor_SMD:C_0603_1608Metric"
"C2","100nF","Capacitor_SMD:C_0603_1608Metric"
"C3","100nF","Capacitor_SMD:C_0603_1608Metric"
"C4","4.7uF","Capacitor_SMD:C_0603_1608Metric"
"C5","8.2pF","Capacitor_SMD:C_0603_1608Metric"
"C6","8.2pF","Capacitor_SMD:C_0603_1608Metric"
"C7","2.2uF","Capacitor_SMD:C_0603_1608Metric"
"C10","10uF","Capacitor_SMD:C_0603_1608Metric"
"C11","22uF","Capacitor_SMD:C_0603_1608Metric"
"C20","10uF/25V","Capacitor_SMD:C_0805_2012Metric"
"C21","10uF","Capacitor_SMD:C_0603_1608Metric"
"C22","100nF","Capacitor_SMD:C_0603_1608Metric"
"C23","100nF","Capacitor_SMD:C_0603_1608Metric"
"C24","100nF","Capacitor_SMD:C_0603_1608Metric"
"C25","100nF","Capacitor_SMD:C_0603_1608Metric"
"C30","100nF","Capacitor_SMD:C_0603_1608Metric"
"C31","100nF","Capacitor_SMD:C_0603_1608Metric"
"C32","100nF","Capacitor_SMD:C_0603_1608Metric"
"C33","100nF","Capacitor_SMD:C_0603_1608Metric"
"C34","100nF","Capacitor_SMD:C_0603_1608Metric"
"C35","100nF","Capacitor_SMD:C_0603_1608Metric"
"C36","100nF","Capacitor_SMD:C_0603_1608Metric"
"C37","100nF","Capacitor_SMD:C_0603_1608Metric"
"C40","100nF","Capacitor_SMD:C_0603_1608Metric"
"C201","10uF/25V","Capacitor_SMD:C_0805_2012Metric"
"C202","1uF/16V","Capacitor_SMD:C_0603_1608Metric"
"C203","10uF/25V","Capacitor_SMD:C_0805_2012Metric"
"C204","10uF/25V","Capacitor_SMD:C_0805_2012Metric"
"C205","100nF","Capacitor_SMD:C_0603_1608Metric"
"C206","3.3nF","Capacitor_SMD:C_0603_1608Metric"
"C207","220nF","Capacitor_SMD:C_0603_1608Metric"
"D1","TPD1E10B06DPYR","Diode_SMD:D_0402_1005Metric"
"D201","SS34","Diode_SMD:D_SMA"
"J1","USB4105-GF-A","Connector_USB:USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal"
"J2","182-025-213R531","MarkerBox:DSUB-25_Socket_NorComp_182-025-213R531"
"J3","SWD","Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical"
"L201","6.8uH","Inductor_SMD:L_Coilcraft_XAL7030-682"
"Q1","AO3401A","Package_TO_SOT_SMD:SOT-23"
"Q2","2N7002","Package_TO_SOT_SMD:SOT-23"
"Q3","2N7002","Package_TO_SOT_SMD:SOT-23"
"R10","330 1%","Resistor_SMD:R_0603_1608Metric"
"R11","330 1%","Resistor_SMD:R_0603_1608Metric"
"R12","330 1%","Resistor_SMD:R_0603_1608Metric"
"R13","330 1%","Resistor_SMD:R_0603_1608Metric"
"R14","330 1%","Resistor_SMD:R_0603_1608Metric"
"R15","330 1%","Resistor_SMD:R_0603_1608Metric"
"R16","330 1%","Resistor_SMD:R_0603_1608Metric"
"R17","330 1%","Resistor_SMD:R_0603_1608Metric"
"R18","330 1%","Resistor_SMD:R_0603_1608Metric"
"R20","1k","Resistor_SMD:R_0603_1608Metric"
"R21","1k","Resistor_SMD:R_0603_1608Metric"
"R22","1k","Resistor_SMD:R_0603_1608Metric"
"R23","1k","Resistor_SMD:R_0603_1608Metric"
"R24","1k","Resistor_SMD:R_0603_1608Metric"
"R25","1k","Resistor_SMD:R_0603_1608Metric"
"R26","1k","Resistor_SMD:R_0603_1608Metric"
"R27","1k","Resistor_SMD:R_0603_1608Metric"
"R28","1k","Resistor_SMD:R_0603_1608Metric"
"R30","100","Resistor_SMD:R_0603_1608Metric"
"R31","100","Resistor_SMD:R_0603_1608Metric"
"R32","100","Resistor_SMD:R_0603_1608Metric"
"R33","100","Resistor_SMD:R_0603_1608Metric"
"R34","100","Resistor_SMD:R_0603_1608Metric"
"R35","100","Resistor_SMD:R_0603_1608Metric"
"R36","100","Resistor_SMD:R_0603_1608Metric"
"R37","100","Resistor_SMD:R_0603_1608Metric"
"R40","47k","Resistor_SMD:R_0603_1608Metric"
"R41","47k","Resistor_SMD:R_0603_1608Metric"
"R42","47k","Resistor_SMD:R_0603_1608Metric"
"R43","47k","Resistor_SMD:R_0603_1608Metric"
"R44","47k","Resistor_SMD:R_0603_1608Metric"
"R45","47k","Resistor_SMD:R_0603_1608Metric"
"R46","47k","Resistor_SMD:R_0603_1608Metric"
"R47","47k","Resistor_SMD:R_0603_1608Metric"
"R50","10k","Resistor_SMD:R_0603_1608Metric"
"R51","10k","Resistor_SMD:R_0603_1608Metric"
"R52","10k","Resistor_SMD:R_0603_1608Metric"
"R60","5.1k","Resistor_SMD:R_0603_1608Metric"
"R61","5.1k","Resistor_SMD:R_0603_1608Metric"
"R70","33k","Resistor_SMD:R_0603_1608Metric"
"R71","1k","Resistor_SMD:R_0603_1608Metric"
"R72","4.7k","Resistor_SMD:R_0603_1608Metric"
"R80","47k","Resistor_SMD:R_0603_1608Metric"
"R81","47k","Resistor_SMD:R_0603_1608Metric"
"R82","47k","Resistor_SMD:R_0603_1608Metric"
"R83","47k","Resistor_SMD:R_0603_1608Metric"
"R84","4.7k","Resistor_SMD:R_0603_1608Metric"
"R85","47k","Resistor_SMD:R_0603_1608Metric"
"R86","47k","Resistor_SMD:R_0603_1608Metric"
"R87","47k","Resistor_SMD:R_0603_1608Metric"
"R88","47k","Resistor_SMD:R_0603_1608Metric"
"R89","0R","Resistor_SMD:R_0603_1608Metric"
"R90","74.5k","Resistor_SMD:R_0603_1608Metric"
"R91","18.2k","Resistor_SMD:R_0603_1608Metric"
"R92","13k","Resistor_SMD:R_0603_1608Metric"
"R93","10k","Resistor_SMD:R_0603_1608Metric"
"R94","100k","Resistor_SMD:R_0603_1608Metric"
"R95","100k","Resistor_SMD:R_0603_1608Metric"
"R96","3.3k","Resistor_SMD:R_0603_1608Metric"
"R97","100","Resistor_SMD:R_0603_1608Metric"
"R98","1k","Resistor_SMD:R_0603_1608Metric"
"TP201","VBUS_SW","TestPoint:TestPoint_Pad_D1.5mm"
"TP202","ISO_VIN","TestPoint:TestPoint_Pad_D1.5mm"
"TP203","ISO_VIN","TestPoint:TestPoint_Pad_D1.5mm"
"U1","STM32F411CEU6","Package_DFN_QFN:QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm"
"U2","TMR 0511","MarkerBox:TMR2_0511_SIP8"
"U3","6N137","Package_DIP:DIP-8_W7.62mm"
"U4","6N137","Package_DIP:DIP-8_W7.62mm"
"U5","6N137","Package_DIP:DIP-8_W7.62mm"
"U6","6N137","Package_DIP:DIP-8_W7.62mm"
"U7","6N137","Package_DIP:DIP-8_W7.62mm"
"U8","6N137","Package_DIP:DIP-8_W7.62mm"
"U9","6N137","Package_DIP:DIP-8_W7.62mm"
"U10","6N137","Package_DIP:DIP-8_W7.62mm"
"U11","6N137","Package_DIP:DIP-8_W7.62mm"
"U12","74HC14","Package_SO:SOIC-14_3.9x8.7mm_P1.27mm"
"U13","74HC14","Package_SO:SOIC-14_3.9x8.7mm_P1.27mm"
"U14","TLV75533PDBVR","Package_TO_SOT_SMD:SOT-23-5"
"U15","SN74LVC06AD","Package_SO:SOIC-14_3.9x8.7mm_P1.27mm"
"U16","SN74LVC06AD","Package_SO:SOIC-14_3.9x8.7mm_P1.27mm"
"U17","TPD2E2U06DCKR","Package_TO_SOT_SMD:SOT-323_SC-70"
"U18","TPD4E05U06DQAR","Package_SON:USON-10_2.5x1.0mm_P0.5mm"
"U19","TPD4E05U06DQAR","Package_SON:USON-10_2.5x1.0mm_P0.5mm"
"U20","TPS61085PWR","Package_SO:TSSOP-8_4.4x3mm_P0.65mm"
"Y1","25MHz 8pF NX3225GA","Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm"

## Code that names these connections

File firmware/src/board_pins.h:

#pragma once
/**
 * GPIO map for the USB-to-DB25 Marker board, hardware revision r7.2.
 * Pin map used by this firmware: PB0–PB7 data, PB8 READY, PA11/PA12 USB,
 * PA13/PA14 SWD, PA15 ISO_PWR_EN, PH0/PH1 HSE. No pin conflict is recorded
 * against the r7.2 manufacturing package.
 * Manufacturing source for the power path (not this header): PR #10 branch
 * cursor/r72-pcb-resync-1f60, BOM hardware/r7.2/fab-review/bom/
 * usb_db25_marker-bom-r7.2-by-ref.csv — R98 = 1 kΩ, R99 is not fitted.
 * docs/r7.2/设计规范-r7.2.md is the design narrative and now matches that.
 *
 * MARKER_D0..D7 : PB0..PB7 (same port for atomic BSRR writes)
 * MARKER_READY  : PB8 (internal optical-output gate; not a DB25 pin)
 * USB_DM/DP     : PA11 / PA12 (STM32 USB FS)
 * SWDIO/SWCLK   : PA13 / PA14 (must remain available for programming/debug)
 * ISO_PWR_EN    : PA15 (active high; keep low until USB is configured and
 *                  the provisional power-up sequence has elapsed)
 */
#include <stdint.h>
#define MKR_GPIO_PORT_DATA   /* GPIOB */ 0
#define MKR_PIN_D0           0u  /* PB0 */
#define MKR_PIN_D1           1u
#define MKR_PIN_D2           2u
#define MKR_PIN_D3           3u
#define MKR_PIN_D4           4u
#define MKR_PIN_D5           5u
#define MKR_PIN_D6           6u
#define MKR_PIN_D7           7u
#define MKR_PIN_READY        8u  /* PB8 */
#define MKR_DATA_MASK        0x00FFu
#define MKR_READY_MASK       (1u << MKR_PIN_READY)
/* r7.2: active-high control for Q1 upstream of the boost converter. */
#define MKR_ISO_PWR_EN_PORT  /* GPIOA */ 0
#define MKR_PIN_ISO_PWR_EN   15u  /* PA15 */

File firmware/core/hse_pins.h:

#ifndef MKR_HSE_PINS_H
#define MKR_HSE_PINS_H
/*
 * PH0 (OSC_IN) and PH1 (OSC_OUT) before HSEON.
 *
 * RM0383 §8.3.12: analog mode disables the output buffer, the Schmitt trigger
 * and the weak pulls. §8.3.14: those pins are GPIO only while HSE is off;
 * setting HSEON gives them to the oscillator and the oscillator wins over GPIO.
 * Program analog and no-pull first, then enable the crystal (HSEBYP stays 0).
 * This does not change the 25 MHz PLL plan.
 */
#include <stdint.h>
#define MKR_HSE_PIN_PH0 0u
#define MKR_HSE_PIN_PH1 1u
#define MKR_GPIO_MODE_ANALOG 3u
#define MKR_HSE_PIN_MODER_MASK 0x0000000Fu
static inline uint32_t mkr_hse_apply_moder(uint32_t moder)
{
    const uint32_t analog = (MKR_GPIO_MODE_ANALOG << (MKR_HSE_PIN_PH0 * 2u)) |
                            (MKR_GPIO_MODE_ANALOG << (MKR_HSE_PIN_PH1 * 2u));
    return (moder & ~MKR_HSE_PIN_MODER_MASK) | analog;
}
static inline uint32_t mkr_hse_apply_pupdr(uint32_t pupdr)
{
    return pupdr & ~MKR_HSE_PIN_MODER_MASK;
}
_Static_assert(MKR_GPIO_MODE_ANALOG == 3u, "RM0383 MODER analog is 11");
_Static_assert(MKR_HSE_PIN_MODER_MASK == 0x0000000Fu, "PH0 and PH1 only");
#endif
